# Keil uVision project SENSOR_PH.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SENSOR_PH
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L1XX_MD
  c include: ..\inc\user_lib;..\inc\LIB\CMSIS\Include;..\inc\LIB\STM32L1xx_StdPeriph_Driver\inc;..\inc\LIB\CMSIS\Device\ST\STM32L1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group src
    ../src/: delay.c init.c kalman.c lora.c main.c ph.c usart.c stm32_rtc.c
  group cmsis
    ../inc/LIB/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_usart.c stm32l1xx_rtc.c stm32l1xx_exti.c stm32l1xx_pwr.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.0.0
